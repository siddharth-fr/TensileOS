#ifndef TENSILE_DISPLAY_PIXEL_GFX_H
#define TENSILE_DISPLAY_PIXEL_GFX_H

#pragma once
// TensileOS Native 320x240 16-Color Framebuffer & 2D Raster Engine
// Runs 100% on the ESP32 silicon. 38,400 bytes RAM (4-bit packed: 2 pixels per byte).
#include <Arduino.h>
#include <string.h>
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"

#define GFX_W 320
#define GFX_H 240
#define GFX_PITCH (GFX_W / 2) // 160 bytes per scanline
#define GFX_FB_SIZE (GFX_PITCH * GFX_H) // 38,400 bytes

// Classic 16-Color Palette
enum WinColor : uint8_t {
  COL_BLACK       = 0,  // #000000
  COL_NAVY        = 1,  // #000080 (Active Titlebar, Selection)
  COL_GREEN       = 2,  // #008000
  COL_TEAL        = 3,  // #008080 (Classic Teal Wallpaper)
  COL_MAROON      = 4,  // #800000
  COL_PURPLE      = 5,  // #800080
  COL_OLIVE       = 6,  // #808000
  COL_SILVER      = 7,  // #C0C0C0 (Window Frame, Taskbar, Buttons)
  COL_GREY        = 8,  // #808080 (3D Shadow, Inactive Titlebar)
  COL_BLUE        = 9,  // #0000FF (Hyperlink, Progress Bar)
  COL_LIME        = 10, // #00FF00
  COL_CYAN        = 11, // #00FFFF
  COL_RED         = 12, // #FF0000 (Close Button)
  COL_MAGENTA     = 13, // #FF00FF (Transparent Mask)
  COL_YELLOW      = 14, // #FFFF00 (Manila Folders)
  COL_WHITE       = 15  // #FFFFFF (3D Light Highlight, Window Interior)
};

// Forward declaration of font tables
extern const uint8_t font8x8_basic[95][8];
extern const uint8_t font6x8_basic[95][8];

class PixelGfx {
 public:
  uint8_t* fb = NULL;
  uint32_t dirtyLines[8]; // 256 bits for 240 scanlines
  SemaphoreHandle_t mtx = NULL;

  // Hardware Clipping Boundaries
  int clipX0 = 0, clipY0 = 0, clipX1 = GFX_W - 1, clipY1 = GFX_H - 1;

  PixelGfx() {
    memset(dirtyLines, 0xFF, sizeof(dirtyLines));
  }

  void begin() {
    if (!fb) fb = (uint8_t*)malloc(GFX_FB_SIZE);
    if (!mtx) mtx = xSemaphoreCreateRecursiveMutex();
    resetClip();
    clear(COL_TEAL);
  }

  void lock()   { if (mtx) xSemaphoreTakeRecursive(mtx, portMAX_DELAY); }
  void unlock() { if (mtx) xSemaphoreGiveRecursive(mtx); }

  inline void setClip(int x0, int y0, int x1, int y1) {
    clipX0 = constrain(x0, 0, GFX_W - 1);
    clipY0 = constrain(y0, 0, GFX_H - 1);
    clipX1 = constrain(x1, 0, GFX_W - 1);
    clipY1 = constrain(y1, 0, GFX_H - 1);
  }

  inline void resetClip() {
    clipX0 = 0; clipY0 = 0;
    clipX1 = GFX_W - 1; clipY1 = GFX_H - 1;
  }

  inline void markDirty(int y) {
    if (y >= 0 && y < GFX_H) dirtyLines[y >> 5] |= (1UL << (y & 31));
  }

  inline void markDirtyRange(int y0, int y1) {
    if (y0 < 0) y0 = 0;
    if (y1 >= GFX_H) y1 = GFX_H - 1;
    for (int y = y0; y <= y1; y++) dirtyLines[y >> 5] |= (1UL << (y & 31));
  }

  void clear(uint8_t c) {
    if (!fb) return;
    lock();
    uint8_t b = (c << 4) | (c & 0x0F);
    memset(fb, b, GFX_FB_SIZE);
    memset(dirtyLines, 0xFF, sizeof(dirtyLines));
    unlock();
  }

  inline void setPixelFast(int x, int y, uint8_t c) {
    if (x < clipX0 || x > clipX1 || y < clipY0 || y > clipY1) return;
    int byteIdx = y * GFX_PITCH + (x >> 1);
    if (x & 1) fb[byteIdx] = (fb[byteIdx] & 0xF0) | (c & 0x0F);
    else       fb[byteIdx] = (fb[byteIdx] & 0x0F) | ((c & 0x0F) << 4);
    markDirty(y);
  }

  void setPixel(int x, int y, uint8_t c) {
    if (x < 0 || y < 0 || x >= GFX_W || y >= GFX_H || !fb) return;
    setPixelFast(x, y, c);
  }

  uint8_t getPixel(int x, int y) {
    if (x < 0 || y < 0 || x >= GFX_W || y >= GFX_H || !fb) return 0;
    int byteIdx = y * GFX_PITCH + (x >> 1);
    return (x & 1) ? (fb[byteIdx] & 0x0F) : (fb[byteIdx] >> 4);
  }

  void drawHLine(int x, int y, int w, uint8_t c) {
    if (y < clipY0 || y > clipY1 || !fb || w <= 0) return;
    if (x < clipX0) { w -= (clipX0 - x); x = clipX0; }
    if (x + w - 1 > clipX1) w = clipX1 - x + 1;
    if (w <= 0) return;

    uint8_t twoPixels = (c << 4) | (c & 0x0F);
    uint8_t* row = fb + y * GFX_PITCH;
    int curX = x;
    int remW = w;

    if (curX & 1) {
      int bIdx = curX >> 1;
      row[bIdx] = (row[bIdx] & 0xF0) | (c & 0x0F);
      curX++;
      remW--;
    }
    if (remW >= 2) {
      int numBytes = remW >> 1;
      memset(row + (curX >> 1), twoPixels, numBytes);
      curX += (numBytes << 1);
      remW -= (numBytes << 1);
    }
    if (remW > 0) {
      int bIdx = curX >> 1;
      row[bIdx] = (row[bIdx] & 0x0F) | ((c & 0x0F) << 4);
    }
    markDirty(y);
  }

  void drawVLine(int x, int y, int h, uint8_t c) {
    if (x < clipX0 || x > clipX1 || !fb) return;
    if (y < clipY0) { h -= (clipY0 - y); y = clipY0; }
    if (y + h - 1 > clipY1) h = clipY1 - y + 1;
    if (h <= 0) return;
    for (int i = 0; i < h; i++) setPixelFast(x, y + i, c);
  }

  void fillRect(int x, int y, int w, int h, uint8_t c) {
    if (!fb || w <= 0 || h <= 0) return;
    if (x < clipX0) { w -= (clipX0 - x); x = clipX0; }
    if (y < clipY0) { h -= (clipY0 - y); y = clipY0; }
    if (x + w - 1 > clipX1) w = clipX1 - x + 1;
    if (y + h - 1 > clipY1) h = clipY1 - y + 1;
    if (w <= 0 || h <= 0) return;

    uint8_t twoPixels = (c << 4) | (c & 0x0F);
    int startX = x;
    int remW = w;
    bool leadingOdd = (startX & 1) != 0;
    int leadingByteIdx = startX >> 1;
    if (leadingOdd) { startX++; remW--; }
    int numFullBytes = remW >> 1;
    int fullBytesOffset = startX >> 1;
    startX += (numFullBytes << 1);
    remW -= (numFullBytes << 1);
    bool trailingOdd = (remW > 0);
    int trailingByteIdx = startX >> 1;

    for (int j = 0; j < h; j++) {
      int cy = y + j;
      uint8_t* row = fb + cy * GFX_PITCH;
      if (leadingOdd) {
        row[leadingByteIdx] = (row[leadingByteIdx] & 0xF0) | (c & 0x0F);
      }
      if (numFullBytes > 0) {
        memset(row + fullBytesOffset, twoPixels, numFullBytes);
      }
      if (trailingOdd) {
        row[trailingByteIdx] = (row[trailingByteIdx] & 0x0F) | ((c & 0x0F) << 4);
      }
    }
    markDirtyRange(y, y + h - 1);
  }

  // Classic 1px Dithered Houndstooth Wireframe Drag Outline
  void drawDitherRect(int x, int y, int w, int h) {
    if (w <= 0 || h <= 0) return;
    // Top & Bottom edges
    for (int i = 0; i < w; i++) {
      uint8_t c1 = ((x + i + y) & 1) ? COL_BLACK : COL_WHITE;
      setPixelFast(x + i, y, c1);
      uint8_t c2 = ((x + i + y + h - 1) & 1) ? COL_BLACK : COL_WHITE;
      setPixelFast(x + i, y + h - 1, c2);
    }
    // Left & Right edges
    for (int j = 0; j < h; j++) {
      uint8_t c1 = ((x + y + j) & 1) ? COL_BLACK : COL_WHITE;
      setPixelFast(x, y + j, c1);
      uint8_t c2 = ((x + w - 1 + y + j) & 1) ? COL_BLACK : COL_WHITE;
      setPixelFast(x + w - 1, y + j, c2);
    }
    markDirtyRange(y, y + h - 1);
  }

  void drawRect(int x, int y, int w, int h, uint8_t c) {
    drawHLine(x, y, w, c);
    drawHLine(x, y + h - 1, w, c);
    drawVLine(x, y, h, c);
    drawVLine(x + w - 1, y, h, c);
  }

  void drawLine(int x0, int y0, int x1, int y1, uint8_t c) {
    int dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1;
    int dy = -abs(y1 - y0), sy = y0 < y1 ? 1 : -1;
    int err = dx + dy, e2;
    while (true) {
      setPixelFast(x0, y0, c);
      if (x0 == x1 && y0 == y1) break;
      e2 = 2 * err;
      if (e2 >= dy) { err += dy; x0 += sx; }
      if (e2 <= dx) { err += dx; y0 += sy; }
    }
  }

  // Classic 2px 3D Bevel Box
  void drawBevelBox(int x, int y, int w, int h, bool sunken) {
    if (w < 4 || h < 4) return;
    uint8_t cLightOuter = sunken ? COL_BLACK : COL_WHITE;
    uint8_t cLightInner = sunken ? COL_GREY  : COL_SILVER;
    uint8_t cDarkInner  = sunken ? COL_SILVER : COL_GREY;
    uint8_t cDarkOuter  = sunken ? COL_WHITE  : COL_BLACK;

    // Top / Left Outer
    drawHLine(x, y, w - 1, cLightOuter);
    drawVLine(x, y, h - 1, cLightOuter);
    // Top / Left Inner
    drawHLine(x + 1, y + 1, w - 3, cLightInner);
    drawVLine(x + 1, y + 1, h - 3, cLightInner);

    // Bottom / Right Inner
    drawHLine(x + 1, y + h - 2, w - 2, cDarkInner);
    drawVLine(x + w - 2, y + 1, h - 2, cDarkInner);
    // Bottom / Right Outer
    drawHLine(x, y + h - 1, w, cDarkOuter);
    drawVLine(x + w - 1, y, h, cDarkOuter);
  }

  // Draw 6x8 Retro Monospace Font Glyph (53 columns on 320px width)
  void drawChar6x8(int x, int y, char c, uint8_t fg, uint8_t bg = 0xFF) {
    if (c < 32 || c > 126 || !fb) return;
    const uint8_t* glyph = font6x8_basic[c - 32];
    for (int row = 0; row < 8; row++) {
      uint8_t line = glyph[row];
      int cy = y + row;
      for (int col = 0; col < 6; col++) {
        int cx = x + col;
        if (line & (1 << (7 - col))) {
          setPixelFast(cx, cy, fg);
        } else if (bg != 0xFF) {
          setPixelFast(cx, cy, bg);
        }
      }
    }
  }

  void drawText6x8(int x, int y, const char* str, uint8_t fg, uint8_t bg = 0xFF) {
    if (!str) return;
    int cx = x;
    while (*str) {
      if (*str == '\n') {
        cx = x;
        y += 8;
      } else {
        drawChar6x8(cx, y, *str, fg, bg);
        cx += 6;
      }
      str++;
    }
  }

  // Draw 8x8 font glyph
  void drawChar(int x, int y, char c, uint8_t fg, uint8_t bg = 0xFF) {
    if (c < 32 || c > 126 || !fb) return;
    const uint8_t* glyph = font8x8_basic[c - 32];
    for (int row = 0; row < 8; row++) {
      uint8_t line = glyph[row];
      int cy = y + row;
      for (int col = 0; col < 8; col++) {
        int cx = x + col;
        if (line & (1 << (7 - col))) {
          setPixelFast(cx, cy, fg);
        } else if (bg != 0xFF) {
          setPixelFast(cx, cy, bg);
        }
      }
    }
  }

  // Draw string with 8x8 font
  void drawText(int x, int y, const char* str, uint8_t fg, uint8_t bg = 0xFF) {
    if (!str) return;
    int cx = x;
    while (*str) {
      if (*str == '\n') {
        cx = x;
        y += 9;
      } else {
        drawChar(cx, y, *str, fg, bg);
        cx += 8;
      }
      str++;
    }
  }

  // Draw 4-bit Sprite with transparent key (Magenta = 13)
  void drawSprite(int x, int y, int w, int h, const uint8_t* data4bpp) {
    if (!data4bpp || !fb) return;
    int p = 0;
    for (int j = 0; j < h; j++) {
      int cy = y + j;
      for (int i = 0; i < w; i += 2) {
        uint8_t b = data4bpp[p++];
        uint8_t c1 = b >> 4;
        uint8_t c2 = b & 0x0F;
        if (c1 != COL_MAGENTA) setPixelFast(x + i, cy, c1);
        if (c2 != COL_MAGENTA) setPixelFast(x + i + 1, cy, c2);
      }
    }
  }

  // Classic 3D Window Frame
  void drawWindow(int x, int y, int w, int h, const char* title, bool active, bool maxi = false) {
    // 1. Soft 2px drop shadow on the right & bottom
    for (int j = 2; j < h + 2; j++) {
      for (int i = w; i < w + 2; i++) {
        int px = x + i, py = y + j;
        if ((px + py) & 1) setPixelFast(px, py, COL_BLACK); // dithered shadow
      }
    }
    for (int j = h; j < h + 2; j++) {
      for (int i = 2; i < w; i++) {
        int px = x + i, py = y + j;
        if ((px + py) & 1) setPixelFast(px, py, COL_BLACK);
      }
    }

    // 2. Window Body & 3D Raised Frame
    fillRect(x, y, w, h, COL_SILVER);
    drawBevelBox(x, y, w, h, false);

    // 3. Titlebar (18px high)
    uint8_t tBg = active ? COL_NAVY : COL_GREY;
    uint8_t tFg = active ? COL_WHITE : COL_SILVER;
    fillRect(x + 3, y + 3, w - 6, 18, tBg);

    // Title text (using crisp 6x8 font with 1px shadow for readability)
    if (title) {
      setClip(x + 6, y + 3, x + w - 46, y + 21);
      drawText6x8(x + 6, y + 8, title, tFg, tBg);
      resetClip();
    }

    // 4. Titlebar Control Buttons (Minimize, Maximize / Restore, Close)
    int bx = x + w - 46;
    int by = y + 5;
    // Minimize [_]
    drawBevelBox(bx, by, 13, 13, false);
    drawHLine(bx + 3, by + 9, 6, COL_BLACK);
    // Maximize / Restore [■] / [❐]
    drawBevelBox(bx + 14, by, 13, 13, false);
    if (maxi) {
      drawRect(bx + 18, by + 3, 5, 5, COL_BLACK);
      drawHLine(bx + 18, by + 4, 5, COL_BLACK);
      drawRect(bx + 16, by + 5, 5, 5, COL_BLACK);
      drawHLine(bx + 16, by + 6, 5, COL_BLACK);
    } else {
      drawRect(bx + 17, by + 3, 7, 7, COL_BLACK);
      drawHLine(bx + 17, by + 4, 7, COL_BLACK);
    }
    // Close [X]
    drawBevelBox(bx + 28, by, 13, 13, false);
    drawChar6x8(bx + 31, by + 3, 'X', COL_BLACK, COL_SILVER);

    // 5. Client Area (Sunken 3D canvas)
    int cw = w - 8;
    int ch = h - 27;
    fillRect(x + 4, y + 23, cw, ch, COL_WHITE);
    drawBevelBox(x + 3, y + 22, cw + 2, ch + 2, true);
  }

  // Classic 3D Push Button
  void drawButton(int x, int y, int w, int h, const char* label, bool pressed) {
    fillRect(x, y, w, h, COL_SILVER);
    drawBevelBox(x, y, w, h, pressed);
    if (label) {
      int textLen = strlen(label) * 6;
      int tx = x + (w - textLen) / 2 + (pressed ? 1 : 0);
      int ty = y + (h - 8) / 2 + (pressed ? 1 : 0);
      drawText6x8(tx, ty, label, COL_BLACK, COL_SILVER);
    }
  }
};

extern PixelGfx gfx;

// Authentic IBM / CP437 6x8 Retro Monospace Font
extern const uint8_t font6x8_basic[95][8] = {
  {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 32 ' '
  {0x20,0x20,0x20,0x20,0x00,0x20,0x00,0x00}, // 33 '!'
  {0x50,0x50,0x00,0x00,0x00,0x00,0x00,0x00}, // 34 '"'
  {0x50,0xF8,0x50,0x50,0xF8,0x50,0x00,0x00}, // 35 '#'
  {0x20,0x78,0xA0,0x70,0x28,0xF0,0x20,0x00}, // 36 '$'
  {0xC8,0xD0,0x20,0x40,0x58,0x48,0x00,0x00}, // 37 '%'
  {0x40,0xA0,0x40,0xA8,0x90,0x68,0x00,0x00}, // 38 '&'
  {0x20,0x20,0x00,0x00,0x00,0x00,0x00,0x00}, // 39 '''
  {0x10,0x20,0x40,0x40,0x40,0x20,0x10,0x00}, // 40 '('
  {0x40,0x20,0x10,0x10,0x10,0x20,0x40,0x00}, // 41 ')'
  {0x00,0x20,0xA8,0x70,0xA8,0x20,0x00,0x00}, // 42 '*'
  {0x00,0x20,0x20,0xF8,0x20,0x20,0x00,0x00}, // 43 '+'
  {0x00,0x00,0x00,0x00,0x00,0x20,0x20,0x40}, // 44 ','
  {0x00,0x00,0x00,0xF8,0x00,0x00,0x00,0x00}, // 45 '-'
  {0x00,0x00,0x00,0x00,0x00,0x20,0x20,0x00}, // 46 '.'
  {0x08,0x10,0x20,0x40,0x80,0x00,0x00,0x00}, // 47 '/'
  {0x70,0x88,0x98,0xA8,0xC8,0x88,0x70,0x00}, // 48 '0'
  {0x20,0x60,0x20,0x20,0x20,0x20,0x70,0x00}, // 49 '1'
  {0x70,0x88,0x08,0x30,0x40,0x80,0xF8,0x00}, // 50 '2'
  {0xF8,0x08,0x10,0x30,0x08,0x88,0x70,0x00}, // 51 '3'
  {0x10,0x30,0x50,0x90,0xF8,0x10,0x10,0x00}, // 52 '4'
  {0xF8,0x80,0xF0,0x08,0x08,0x88,0x70,0x00}, // 53 '5'
  {0x38,0x40,0x80,0xF0,0x88,0x88,0x70,0x00}, // 54 '6'
  {0xF8,0x08,0x10,0x20,0x40,0x40,0x40,0x00}, // 55 '7'
  {0x70,0x88,0x88,0x70,0x88,0x88,0x70,0x00}, // 56 '8'
  {0x70,0x88,0x88,0x78,0x08,0x10,0xE0,0x00}, // 57 '9'
  {0x00,0x20,0x00,0x00,0x20,0x00,0x00,0x00}, // 58 ':'
  {0x00,0x20,0x00,0x00,0x20,0x20,0x40,0x00}, // 59 ';'
  {0x08,0x10,0x20,0x40,0x20,0x10,0x08,0x00}, // 60 '<'
  {0x00,0xF8,0x00,0xF8,0x00,0x00,0x00,0x00}, // 61 '='
  {0x40,0x20,0x10,0x08,0x10,0x20,0x40,0x00}, // 62 '>'
  {0x70,0x88,0x08,0x30,0x20,0x00,0x20,0x00}, // 63 '?'
  {0x70,0x88,0xB8,0xA8,0xB8,0x80,0x70,0x00}, // 64 '@'
  {0x70,0x88,0x88,0xF8,0x88,0x88,0x88,0x00}, // 65 'A'
  {0xF0,0x88,0x88,0xF0,0x88,0x88,0xF0,0x00}, // 66 'B'
  {0x70,0x88,0x80,0x80,0x80,0x88,0x70,0x00}, // 67 'C'
  {0xF0,0x88,0x88,0x88,0x88,0x88,0xF0,0x00}, // 68 'D'
  {0xF8,0x80,0x80,0xF0,0x80,0x80,0xF8,0x00}, // 69 'E'
  {0xF8,0x80,0x80,0xF0,0x80,0x80,0x80,0x00}, // 70 'F'
  {0x70,0x88,0x80,0xB8,0x88,0x88,0x70,0x00}, // 71 'G'
  {0x88,0x88,0x88,0xF8,0x88,0x88,0x88,0x00}, // 72 'H'
  {0x70,0x20,0x20,0x20,0x20,0x20,0x70,0x00}, // 73 'I'
  {0x18,0x08,0x08,0x08,0x08,0x88,0x70,0x00}, // 74 'J'
  {0x88,0x90,0xA0,0xC0,0xA0,0x90,0x88,0x00}, // 75 'K'
  {0x80,0x80,0x80,0x80,0x80,0x80,0xF8,0x00}, // 76 'L'
  {0x88,0xD8,0xA8,0x88,0x88,0x88,0x88,0x00}, // 77 'M'
  {0x88,0xC8,0xA8,0x98,0x88,0x88,0x88,0x00}, // 78 'N'
  {0x70,0x88,0x88,0x88,0x88,0x88,0x70,0x00}, // 79 'O'
  {0xF0,0x88,0x88,0xF0,0x80,0x80,0x80,0x00}, // 80 'P'
  {0x70,0x88,0x88,0x88,0xA8,0x90,0x68,0x00}, // 81 'Q'
  {0xF0,0x88,0x88,0xF0,0xA0,0x90,0x88,0x00}, // 82 'R'
  {0x70,0x88,0x80,0x70,0x08,0x88,0x70,0x00}, // 83 'S'
  {0xF8,0x20,0x20,0x20,0x20,0x20,0x20,0x00}, // 84 'T'
  {0x88,0x88,0x88,0x88,0x88,0x88,0x70,0x00}, // 85 'U'
  {0x88,0x88,0x88,0x88,0x88,0x50,0x20,0x00}, // 86 'V'
  {0x88,0x88,0x88,0x88,0xA8,0xD8,0x88,0x00}, // 87 'W'
  {0x88,0x88,0x50,0x20,0x50,0x88,0x88,0x00}, // 88 'X'
  {0x88,0x88,0x50,0x20,0x20,0x20,0x20,0x00}, // 89 'Y'
  {0xF8,0x08,0x10,0x20,0x40,0x80,0xF8,0x00}, // 90 'Z'
  {0x70,0x40,0x40,0x40,0x40,0x40,0x70,0x00}, // 91 '['
  {0x80,0x40,0x20,0x10,0x08,0x00,0x00,0x00}, // 92 '\'
  {0x70,0x10,0x10,0x10,0x10,0x10,0x70,0x00}, // 93 ']'
  {0x20,0x50,0x88,0x00,0x00,0x00,0x00,0x00}, // 94 '^'
  {0x00,0x00,0x00,0x00,0x00,0x00,0xF8,0x00}, // 95 '_'
  {0x40,0x20,0x00,0x00,0x00,0x00,0x00,0x00}, // 96 '`'
  {0x00,0x00,0x70,0x08,0x78,0x88,0x78,0x00}, // 97 'a'
  {0x80,0x80,0xF0,0x88,0x88,0x88,0xF0,0x00}, // 98 'b'
  {0x00,0x00,0x70,0x88,0x80,0x88,0x70,0x00}, // 99 'c'
  {0x08,0x08,0x78,0x88,0x88,0x88,0x78,0x00}, // 100 'd'
  {0x00,0x00,0x70,0x88,0xF8,0x80,0x70,0x00}, // 101 'e'
  {0x30,0x48,0x40,0xE0,0x40,0x40,0x40,0x00}, // 102 'f'
  {0x00,0x00,0x78,0x88,0x88,0x78,0x08,0x70}, // 103 'g'
  {0x80,0x80,0xF0,0x88,0x88,0x88,0x88,0x00}, // 104 'h'
  {0x20,0x00,0x60,0x20,0x20,0x20,0x70,0x00}, // 105 'i'
  {0x10,0x00,0x30,0x10,0x10,0x10,0x90,0x60}, // 106 'j'
  {0x80,0x80,0x90,0xA0,0xC0,0xA0,0x90,0x00}, // 107 'k'
  {0x60,0x20,0x20,0x20,0x20,0x20,0x70,0x00}, // 108 'l'
  {0x00,0x00,0xD0,0xA8,0xA8,0x88,0x88,0x00}, // 109 'm'
  {0x00,0x00,0xF0,0x88,0x88,0x88,0x88,0x00}, // 110 'n'
  {0x00,0x00,0x70,0x88,0x88,0x88,0x70,0x00}, // 111 'o'
  {0x00,0x00,0xF0,0x88,0x88,0xF0,0x80,0x80}, // 112 'p'
  {0x00,0x00,0x78,0x88,0x88,0x78,0x08,0x08}, // 113 'q'
  {0x00,0x00,0xB0,0xC8,0x80,0x80,0x80,0x00}, // 114 'r'
  {0x00,0x00,0x78,0x80,0x70,0x08,0xF0,0x00}, // 115 's'
  {0x40,0x40,0xE0,0x40,0x40,0x48,0x30,0x00}, // 116 't'
  {0x00,0x00,0x88,0x88,0x88,0x88,0x78,0x00}, // 117 'u'
  {0x00,0x00,0x88,0x88,0x88,0x50,0x20,0x00}, // 118 'v'
  {0x00,0x00,0x88,0x88,0xA8,0xD8,0x88,0x00}, // 119 'w'
  {0x00,0x00,0x88,0x50,0x20,0x50,0x88,0x00}, // 120 'x'
  {0x00,0x00,0x88,0x88,0x78,0x08,0x70,0x00}, // 121 'y'
  {0x00,0x00,0xF8,0x10,0x20,0x40,0xF8,0x00}, // 122 'z'
  {0x18,0x20,0x20,0xC0,0x20,0x20,0x18,0x00}, // 123 '{'
  {0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x00}, // 124 '|'
  {0xC0,0x20,0x20,0x18,0x20,0x20,0xC0,0x00}, // 125 '}'
  {0x40,0xA8,0x10,0x00,0x00,0x00,0x00,0x00}  // 126 '~'
};

// Standard IBM 8x8 font data definition
extern const uint8_t font8x8_basic[95][8] = {
  {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 32 ' '
  {0x18,0x3C,0x3C,0x18,0x18,0x00,0x18,0x00}, // 33 '!'
  {0x66,0x66,0x24,0x00,0x00,0x00,0x00,0x00}, // 34 '"'
  {0x6C,0x6C,0xFE,0x6C,0xFE,0x6C,0x6C,0x00}, // 35 '#'
  {0x18,0x3E,0x60,0x3C,0x06,0x7C,0x18,0x00}, // 36 '$'
  {0x00,0x63,0x66,0x0C,0x18,0x33,0x63,0x00}, // 37 '%'
  {0x38,0x6C,0x38,0x76,0xDC,0xCC,0x76,0x00}, // 38 '&'
  {0x60,0x60,0xC0,0x00,0x00,0x00,0x00,0x00}, // 39 '''
  {0x0C,0x18,0x30,0x30,0x30,0x18,0x0C,0x00}, // 40 '('
  {0x30,0x18,0x0C,0x0C,0x0C,0x18,0x30,0x00}, // 41 ')'
  {0x00,0x66,0x3C,0xFF,0x3C,0x66,0x00,0x00}, // 42 '*'
  {0x00,0x18,0x18,0x7E,0x18,0x18,0x00,0x00}, // 43 '+'
  {0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x30}, // 44 ','
  {0x00,0x00,0x00,0x7E,0x00,0x00,0x00,0x00}, // 45 '-'
  {0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00}, // 46 '.'
  {0x06,0x0C,0x18,0x30,0x60,0xC0,0x80,0x00}, // 47 '/'
  {0x7C,0xC6,0xCE,0xD6,0xE6,0xC6,0x7C,0x00}, // 48 '0'
  {0x18,0x38,0x18,0x18,0x18,0x18,0x7E,0x00}, // 49 '1'
  {0x7C,0xC6,0x06,0x1C,0x30,0x60,0xFE,0x00}, // 50 '2'
  {0x7C,0xC6,0x06,0x3C,0x06,0xC6,0x7C,0x00}, // 51 '3'
  {0x1C,0x3C,0x6C,0xCC,0xFE,0x0C,0x1E,0x00}, // 52 '4'
  {0xFE,0xC0,0xFC,0x06,0x06,0xC6,0x7C,0x00}, // 53 '5'
  {0x7C,0xC6,0xC0,0xFC,0xC6,0xC6,0x7C,0x00}, // 54 '6'
  {0xFE,0x06,0x0C,0x18,0x30,0x60,0x60,0x00}, // 55 '7'
  {0x7C,0xC6,0xC6,0x7C,0xC6,0xC6,0x7C,0x00}, // 56 '8'
  {0x7C,0xC6,0xC6,0x7E,0x06,0xC6,0x7C,0x00}, // 57 '9'
  {0x00,0x18,0x18,0x00,0x18,0x18,0x00,0x00}, // 58 ':'
  {0x00,0x18,0x18,0x00,0x18,0x18,0x30,0x00}, // 59 ';'
  {0x06,0x0C,0x18,0x30,0x18,0x0C,0x06,0x00}, // 60 '<'
  {0x00,0x00,0x7E,0x00,0x7E,0x00,0x00,0x00}, // 61 '='
  {0x60,0x30,0x18,0x0C,0x18,0x30,0x60,0x00}, // 62 '>'
  {0x7C,0xC6,0x0C,0x18,0x18,0x00,0x18,0x00}, // 63 '?'
  {0x7C,0xC6,0xDE,0xDE,0xDC,0xC0,0x7C,0x00}, // 64 '@'
  {0x38,0x6C,0xC6,0xFE,0xC6,0xC6,0xC6,0x00}, // 65 'A'
  {0xFC,0x66,0x66,0x7C,0x66,0x66,0xFC,0x00}, // 66 'B'
  {0x3C,0x66,0xC0,0xC0,0xC0,0x66,0x3C,0x00}, // 67 'C'
  {0xF8,0x6C,0x66,0x66,0x66,0x6C,0xF8,0x00}, // 68 'D'
  {0xFE,0x62,0x68,0x78,0x68,0x62,0xFE,0x00}, // 69 'E'
  {0xFE,0x62,0x68,0x78,0x68,0x60,0xF0,0x00}, // 70 'F'
  {0x3C,0x66,0xC0,0xC0,0xCE,0x66,0x3E,0x00}, // 71 'G'
  {0xC6,0xC6,0xC6,0xFE,0xC6,0xC6,0xC6,0x00}, // 72 'H'
  {0x3C,0x18,0x18,0x18,0x18,0x18,0x3C,0x00}, // 73 'I'
  {0x1E,0x0C,0x0C,0x0C,0xCC,0xCC,0x78,0x00}, // 74 'J'
  {0xE6,0x66,0x6C,0x78,0x6C,0x66,0xE6,0x00}, // 75 'K'
  {0xF0,0x60,0x60,0x60,0x62,0x66,0xFE,0x00}, // 76 'L'
  {0xC6,0xEE,0xFE,0xFE,0xD6,0xC6,0xC6,0x00}, // 77 'M'
  {0xC6,0xE6,0xF6,0xDE,0xCE,0xC6,0xC6,0x00}, // 78 'N'
  {0x7C,0xC6,0xC6,0xC6,0xC6,0xC6,0x7C,0x00}, // 79 'O'
  {0xFC,0x66,0x66,0x7C,0x60,0x60,0xF0,0x00}, // 80 'P'
  {0x7C,0xC6,0xC6,0xC6,0xD6,0xDE,0x7C,0x0E}, // 81 'Q'
  {0xFC,0x66,0x66,0x7C,0x6C,0x66,0xE6,0x00}, // 82 'R'
  {0x7C,0xC6,0x60,0x38,0x0C,0xC6,0x7C,0x00}, // 83 'S'
  {0x7E,0x5A,0x18,0x18,0x18,0x18,0x3C,0x00}, // 84 'T'
  {0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0x7C,0x00}, // 85 'U'
  {0xC6,0xC6,0xC6,0xC6,0x6C,0x38,0x10,0x00}, // 86 'V'
  {0xC6,0xC6,0xD6,0xFE,0xFE,0xEE,0xC6,0x00}, // 87 'W'
  {0xC6,0xC6,0x6C,0x38,0x6C,0xC6,0xC6,0x00}, // 88 'X'
  {0x66,0x66,0x66,0x3C,0x18,0x18,0x3C,0x00}, // 89 'Y'
  {0xFE,0xC6,0x0C,0x18,0x30,0x66,0xFE,0x00}, // 90 'Z'
  {0x3C,0x30,0x30,0x30,0x30,0x30,0x3C,0x00}, // 91 '['
  {0xC0,0x60,0x30,0x18,0x0C,0x06,0x02,0x00}, // 92 '\'
  {0x3C,0x0C,0x0C,0x0C,0x0C,0x0C,0x3C,0x00}, // 93 ']'
  {0x10,0x38,0x6C,0xC6,0x00,0x00,0x00,0x00}, // 94 '^'
  {0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0x00}, // 95 '_'
  {0x30,0x18,0x0C,0x00,0x00,0x00,0x00,0x00}, // 96 '`'
  {0x00,0x00,0x78,0x0C,0x7C,0xCC,0x76,0x00}, // 97 'a'
  {0xE0,0x60,0x7C,0x66,0x66,0x66,0xDC,0x00}, // 98 'b'
  {0x00,0x00,0x7C,0xC6,0xC0,0xC6,0x7C,0x00}, // 99 'c'
  {0x1C,0x0C,0x7C,0xCC,0xCC,0xCC,0x76,0x00}, // 100 'd'
  {0x00,0x00,0x7C,0xC6,0xFE,0xC0,0x7C,0x00}, // 101 'e'
  {0x38,0x6C,0x60,0xF0,0x60,0x60,0xF0,0x00}, // 102 'f'
  {0x00,0x00,0x76,0xCC,0xCC,0x7C,0x0C,0xF8}, // 103 'g'
  {0xE0,0x60,0x6C,0x76,0x66,0x66,0xE6,0x00}, // 104 'h'
  {0x18,0x00,0x38,0x18,0x18,0x18,0x3C,0x00}, // 105 'i'
  {0x0C,0x00,0x1C,0x0C,0x0C,0xCC,0xCC,0x78}, // 106 'j'
  {0xE0,0x60,0x66,0x6C,0x78,0x6C,0xE6,0x00}, // 107 'k'
  {0x38,0x18,0x18,0x18,0x18,0x18,0x3C,0x00}, // 108 'l'
  {0x00,0x00,0xEC,0xFE,0xD6,0xD6,0xD6,0x00}, // 109 'm'
  {0x00,0x00,0xDC,0x66,0x66,0x66,0x66,0x00}, // 110 'n'
  {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0x7C,0x00}, // 111 'o'
  {0x00,0x00,0xDC,0x66,0x66,0x7C,0x60,0xF0}, // 112 'p'
  {0x00,0x00,0x76,0xCC,0xCC,0x7C,0x0C,0x1E}, // 113 'q'
  {0x00,0x00,0xDC,0x76,0x60,0x60,0xF0,0x00}, // 114 'r'
  {0x00,0x00,0x7C,0xC0,0x7C,0x06,0xFC,0x00}, // 115 's'
  {0x30,0x30,0xFC,0x30,0x30,0x34,0x18,0x00}, // 116 't'
  {0x00,0x00,0xCC,0xCC,0xCC,0xCC,0x76,0x00}, // 117 'u'
  {0x00,0x00,0xC6,0xC6,0xC6,0x6C,0x38,0x00}, // 118 'v'
  {0x00,0x00,0xC6,0xD6,0xFE,0xFE,0x6C,0x00}, // 119 'w'
  {0x00,0x00,0xC6,0x6C,0x38,0x6C,0xC6,0x00}, // 120 'x'
  {0x00,0x00,0xC6,0xC6,0xCE,0x76,0x06,0xFC}, // 121 'y'
  {0x00,0x00,0xFE,0x8C,0x18,0x32,0xFE,0x00}, // 122 'z'
  {0x0E,0x18,0x18,0x70,0x18,0x18,0x0E,0x00}, // 123 '{'
  {0x18,0x18,0x18,0x00,0x18,0x18,0x18,0x00}, // 124 '|'
  {0x70,0x18,0x18,0x0E,0x18,0x18,0x70,0x00}, // 125 '}'
  {0x76,0xDC,0x00,0x00,0x00,0x00,0x00,0x00}  // 126 '~'
};


#endif // TENSILE_DISPLAY_PIXEL_GFX_H
